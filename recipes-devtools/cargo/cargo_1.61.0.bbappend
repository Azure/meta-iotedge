unset OPENSSL_SYS_USE_PKG_CONFIG
