unset LIBGIT2_SYS_USE_PKG_CONFIG

