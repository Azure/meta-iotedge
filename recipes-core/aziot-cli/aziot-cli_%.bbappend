SRC_URI += "file://0001-Fix-edgelet-iotedge-code.patch"
